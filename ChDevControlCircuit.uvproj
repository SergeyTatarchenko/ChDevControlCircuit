# Keil uVision project ChDevControlCircuit.uvproj, settings and files
target TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ChDevControlCircuit +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: \Code\System;.\Code\FreeRTOS;.\Code\FreeRTOS\include;.\Code\Main;.\Code\System;.\Code\Drivers;.\Code\Utility_Func;.\Code\OBJ;.\Code\OBJ_MODEL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Code/Main/: FreeRTOSConfig.h main.c service_tasks.c global.c global.h user_tasks.c obj_model_config.h
  group OBJ_MODEL
    ./Code/OBJ_MODEL/: OBJ_MODEL.h OBJ_MODEL.c
  group OBJ
    ./Code/OBJ/: obj_ID.h List_OBJ.c
  group Utility_Func
    ./Code/Utility_Func/: PID.h PID.c
  group Drivers
    ./Code/Drivers/: mcp23x17.c adg72x.c mcp3221.c
  group System
    ./Code/System/: startup_stm32f10x_md.s system_stm32f10x.c i2c.c adc.c dma.c pwm.c Util.c usart.c ext.c can.c
  group FreeRTOS
    ./Code/FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_2.c
